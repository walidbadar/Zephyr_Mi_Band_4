## boards/xiaomi/mi_band_4/board.yml
```yaml
board:
  name: mi_band_4
  full_name: Mi Band 4 Wearable
  vendor: renesas
  socs:
  - name: da14697
```
